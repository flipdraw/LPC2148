 #include <LPC21xx.H>
void delay()
	{
	int i;
	for(i=0;i<70000;i++);
	}
int main()
{	   int i,j,k,m,a[10];
	PINSEL0=0x00000000;
	PINSEL1=0x00000000;	
	IODIR0=0xffffffff;
	while(1)
	{	
		a[0]=(1<<0)|(1<<1)|(1<<2)|(1<<3)|(1<<4)|(1<<5);
		a[1]=(1<<1)|(1<<2);
		a[2]=(1<<0)|(1<<1)|(1<<3)|(1<<4)|(1<<6);	  
	    a[3]=(1<<0)|(1<<1)|(1<<6)|(1<<2)|(1<<3);		
		a[4]=(1<<5)|(1<<6)|(1<<1)|(1<<2);			  
		a[5]=(1<<0)|(1<<5)|(1<<6)|(1<<2)|(1<<3);	
		a[6]=(1<<0)|(1<<2)|(1<<3)|(1<<4)|(1<<5)|(1<<6);							  
		a[7]=(1<<0)|(1<<1)|(1<<2);		
		a[8]=(1<<1)|(1<<2)|(1<<0)|(1<<3)|(1<<4)|(1<<5)|(1<<6);						
		a[9]=(1<<0)|(1<<1)|(1<<2)|(1<<3)|(1<<5)|(1<<6);										
	   for(j=0;j<10;j++)
	   {
	          for(i=0;i<10;i++)	  
	   {
		{		
		      IOSET0=1<<9;
			  for(m=0;m<5000;m++)
			     {
			  	  IOSET0=a[j];
			  	 }
				IOCLR0=a[j];
			   IOCLR0=1<<9;
			   IOSET0=1<<8;	
			 for(m=0;m<5000;m++)
			        {
              IOSET0=a[i];
			  	    }	
				IOCLR0=a[i];  
				IOCLR0=1<<8;
			}
     	}
		
	 }
  }
}
